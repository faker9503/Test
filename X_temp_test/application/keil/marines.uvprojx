# Keil uVision project marines.uvprojx, settings and files
target marines (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: marines +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA WSF_TRACE_ENABLED AM_DEBUG_PRINTF AM_PART_APOLLO2 AM_FREERTOS keil
  c include: ..\..\application;..\am_osal;..\task_ble;..\task_ota;..\task_motion;..\task_factory;..\task_memory;..\task_protocol;..\..\..\Platform;..\..\..\Platform\ble\ambiq_ble\apps\ancs;..\..\..\Platform\ble\ambiq_ble\profiles\ancc;..\..\..\Platform\dev;..\..\..\Platform\mcu\apollo2;..\..\..\Platform\mcu\apollo2\hal;..\..\..\Platform\mcu\apollo2\regs;..\..\..\Platform\ble\exactle\apollo-host\projects\common;..\..\..\Platform\ble\exactle\sw\apps\app;..\..\..\Platform\ble\exactle\sw\apps\app\include;..\..\..\Platform\ble\exactle\sw\hci\ambiq;..\..\..\Platform\ble\exactle\sw\hci\include;..\..\..\Platform\ble\exactle\sw\profiles\gatt;..\..\..\Platform\ble\exactle\sw\profiles\uribeacon;..\..\..\Platform\ble\exactle\sw\sec\common;..\..\..\Platform\ble\exactle\sw\sec\include;..\..\..\Platform\ble\exactle\sw\stack\cfg;..\..\..\Platform\ble\exactle\sw\stack\hci;..\..\..\Platform\ble\exactle\sw\stack\include;..\..\..\Platform\ble\exactle\ws-core\include;..\..\..\Platform\ble\exactle\ws-core\sw\util;..\..\..\Platform\ble\exactle\ws-core\sw\wsf\ambiq;..\..\..\Platform\ble\exactle\ws-core\sw\wsf\include;..\..\..\Platform\utils;..\..\..\Platform\bsp;..\..\..\Platform\mcu\apollo2\hal;..\..\..\Platform\mcu\apollo2\regs;..\..\..\Platform\ble\ambiq_ble\profiles\amdtps;..\..\..\Platform\ble\ambiq_ble\profiles\amdtpcommon;..\..\..\Platform\ble\ambiq_ble\services;..\..\..\Platform\ble\exactle\sw\services;..\..\..\ThirdParty;..\..\..\ThirdParty\FreeRTOS9\Source\portable\Keil\AMapollo2;..\..\..\ThirdParty\FreeRTOS9\Source\portable\MemMang;..\..\..\ThirdParty\FreeRTOS9\Source\include;..\..\..\ThirdParty\ctaocrypt\inc;..\..\..\ThirdParty\crypto\include
  asm include: ..\..\..\Platform\ble\ambiq_ble\apps\ancs
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\marines.sct
  link misc: --keep=am_hal_global.o(.data)
  group main
    ../: main.c config.h version.h
  group task_rtc
    ../task_rtc/: task_rtc.c
  group task_ble
    ../task_ble/: radio_task.c
  group task_ota
    ../task_ota/: task_ota.c
  group task_system
    ../task_system/: task_system.c
  group task_factory
    ../task_factory/: task_factory.c
  group task_motion
    ../task_motion/: task_motion.c
  group task_memory
    ../task_memory/: task_memory.c
  group task_protocol
    ../task_protocol/: fifo.c ble_tlv.c logic_linker.c logic_protocol.c task_protocol.c
  group platform_cmsis
    ./: startup_keil.s
  group platform_mcu
    ../../../Platform/mcu/apollo2/hal/: am_hal_adc.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
  group platform_dev
    ../../../Platform/dev/: am_devices_button.c am_devices_em9304.c am_devices_led.c am_devices_lis3mdl.c am_devices_spiflash.c
  group platform_bsp
    ../../../Platform/bsp/: am_bsp.c bsp_battery.c bsp_debug.c bsp_flash.c bsp_init.c
  group platform_utils
    ../../../Platform/utils/: am_util.h am_util_cmdline.c am_util_cmdline.h am_util_debug.c am_util_debug.h am_util_delay.c am_util_delay.h am_util_faultisr.c am_util_id.c am_util_id.h am_util_math.c am_util_math.h am_util_plot.c am_util_plot.h am_util_regdump.c am_util_regdump.h am_util_ring_buffer.c am_util_ring_buffer.h am_util_stdio.c am_util_stdio.h am_util_stopwatch.c am_util_stopwatch.h am_util_string.c am_util_string.h am_util_stxetx.c am_util_stxetx.h am_util_tap_detect.c am_util_tap_detect.h am_util_time.c am_util_time.h
  group platform_ble_app
    ../../../Platform/ble/ambiq_ble/profiles/ancc/: ancc_main.c
    ../../../Platform/ble/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../Platform/ble/ambiq_ble/profiles/amdtps/: amdtps_main.c
    ../../../Platform/ble/ambiq_ble/apps/ancs/: ancs_main.c
  group platform_ble_service
    ../../../Platform/ble/ambiq_ble/services/: svc_amdtp.c
    ../../../Platform/ble/ambiq_ble/profiles/amdtpcommon/: amdtp_common.c
    ../../../Platform/ble/exactle/sw/services/: svc_core.c svc_dis.c
  group platform_ble_gatt
    ../../../Platform/ble/exactle/sw/profiles/gatt/: gatt_main.c
  group platform_ble_stack
    ../../../Platform/ble/exactle/sw/hci/ambiq/em9304/: em9304_patches.c hci_drv_em9304.c
    ../../../Platform/ble/exactle/projects/generic/stacklib/keil/Cortex-M4/: stacklib.lib
    ../../../Platform/ble/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../../../Platform/ble/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
    ../../../Platform/ble/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../../Platform/ble/exactle/sw/stack/cfg/: cfg_stack.c
    ../../../Platform/ble/exactle/sw/stack/hci/: hci_main.c
    ../../../Platform/ble/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../Platform/ble/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../../../Platform/ble/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
  group thirdparty_freertos
    ../../../ThirdParty/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
    ../../../ThirdParty/FreeRTOS9/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS9/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../am_osal/: am_app_utils.c am_msg_task.c msg_queue.c
  group thirdparty_crypto
    ../../../ThirdParty/crypto/src/: crypto_ecdh.c crypto_hmac.c
  group thirdparty_ctaocrypt
    ../../../ThirdParty/ctaocrypt/src/: aes.c aes_function.c hmac.c misc.c sha256.c
